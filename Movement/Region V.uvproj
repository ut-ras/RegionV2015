# Keil uVision project Region V.uvproj, settings and files
target RASDemo (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RASDemo
  c flags: Optim=1
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..\;..\..\;C:\;..\StellarisWare;..\..\StellarisWare;C:\StellarisWare;inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  link misc: --entry=ResetHandler --first=__Vectors --datacompressor=off
  group Source
    ./: Startup.c Main.c
  group Libs
    ../RASLib/output/: RASLib.lib
